v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -210 -120 -140 -120 {
lab=in}
N -140 -120 -140 -80 {
lab=in}
N -140 -50 -120 -50 {
lab=in}
N -120 -120 -120 -50 {
lab=in}
N -150 -120 -120 -120 {
lab=in}
N -140 -20 -140 20 {
lab=#net1}
N -200 -50 -180 -50 {
lab=clk}
N -200 -50 -200 50 {
lab=clk}
N -200 50 -180 50 {
lab=clk}
N -210 0 -200 0 {
lab=clk}
N -210 120 -140 120 {
lab=gnd}
N -140 80 -140 120 {
lab=gnd}
N -120 50 -120 120 {
lab=gnd}
N 220 -40 220 -0 {
lab=#net1}
N -0 -120 70 -120 {
lab=in}
N 130 -120 220 -120 {
lab=#net2}
N 220 -120 220 -100 {
lab=#net2}
N 420 -120 420 -90 {
lab=#net2}
N 420 -30 420 0 {
lab=#net1}
N 220 -0 420 0 {
lab=#net1}
N 670 -120 670 -80 {
lab=#net3}
N 670 -50 690 -50 {
lab=#net3}
N 690 -120 690 -50 {
lab=#net3}
N 670 -20 670 20 {
lab=#net4}
N 610 -50 630 -50 {
lab=#net5}
N 610 -50 610 50 {
lab=#net5}
N 610 50 630 50 {
lab=#net5}
N 670 80 670 120 {
lab=#net6}
N 670 50 690 50 {
lab=#net6}
N 690 50 690 120 {
lab=#net6}
N -140 50 -120 50 {
lab=gnd}
N -120 50 -120 120 {
lab=gnd}
N -140 120 -120 120 {
lab=gnd}
N -200 50 -200 190 {
lab=clk}
N -200 190 -200 200 {
lab=clk}
N 620 120 690 120 {
lab=#net6}
N 550 -120 550 -70 {
lab=#net2}
N 490 -30 520 -30 {
lab=#net1}
N 490 -30 490 -0 {
lab=#net1}
N 580 -30 600 -30 {
lab=#net1}
N 600 -30 600 -0 {
lab=#net1}
N 550 -30 550 0 {
lab=#net1}
N -140 -50 -120 -50 {
lab=in}
N -140 -20 -140 20 {
lab=#net1}
N -200 -50 -180 -50 {
lab=clk}
N -200 -50 -200 50 {
lab=clk}
N -200 50 -180 50 {
lab=clk}
N -140 50 -120 50 {
lab=gnd}
N -120 -120 0 -120 {
lab=in}
N 0 -120 0 -80 {
lab=in}
N 0 -20 0 20 {
lab=#net1}
N 0 80 0 120 {
lab=gnd}
N -120 120 0 120 {
lab=gnd}
N -60 50 -40 50 {
lab=clk}
N -60 -50 -60 50 {
lab=clk}
N -60 -50 -40 -50 {
lab=clk}
N -200 0 -60 0 {
lab=clk}
N -200 200 -70 200 {
lab=clk}
N -0 -50 20 -50 {
lab=in}
N 20 -120 20 -50 {
lab=in}
N -0 50 30 50 {
lab=#net7}
N 30 50 30 120 {
lab=#net7}
N -140 -20 -0 -20 {
lab=#net1}
N 840 -120 840 -80 {
lab=#net3}
N 840 -50 860 -50 {
lab=#net3}
N 860 -120 860 -50 {
lab=#net3}
N 840 -20 840 20 {
lab=#net4}
N 780 -50 800 -50 {
lab=#net5}
N 780 -50 780 50 {
lab=#net5}
N 780 50 800 50 {
lab=#net5}
N 840 80 840 120 {
lab=#net6}
N 840 50 860 50 {
lab=#net6}
N 860 50 860 120 {
lab=#net6}
N 610 0 780 0 {
lab=#net5}
N 670 -20 840 -20 {
lab=#net4}
N 1000 -120 1000 -80 {
lab=#net8}
N 1000 -50 1020 -50 {
lab=#net9}
N 1020 -120 1020 -50 {
lab=#net9}
N 1000 -20 1000 20 {
lab=#net10}
N 940 -50 960 -50 {
lab=#net11}
N 940 -50 940 50 {
lab=#net11}
N 940 50 960 50 {
lab=#net11}
N 1000 80 1000 120 {
lab=#net12}
N 1020 50 1020 120 {
lab=#net12}
N 1360 -40 1360 0 {
lab=#net10}
N 1140 -120 1210 -120 {
lab=#net9}
N 1270 -120 1360 -120 {
lab=#net13}
N 1360 -120 1360 -100 {
lab=#net13}
N 1560 -120 1560 -90 {
lab=#net13}
N 1560 -30 1560 0 {
lab=#net10}
N 1360 0 1560 0 {
lab=#net10}
N 1830 -120 1830 -80 {
lab=#net13}
N 1830 -50 1850 -50 {
lab=#net13}
N 1850 -120 1850 -50 {
lab=#net13}
N 1830 -20 1830 20 {
lab=#net14}
N 1770 -50 1790 -50 {
lab=#net11}
N 1770 -50 1770 50 {
lab=#net11}
N 1770 50 1790 50 {
lab=#net11}
N 1830 80 1830 120 {
lab=#net12}
N 1830 50 1850 50 {
lab=#net12}
N 1850 50 1850 120 {
lab=#net12}
N 1000 50 1020 50 {
lab=#net12}
N 1020 50 1020 120 {
lab=#net12}
N 1000 120 1020 120 {
lab=#net12}
N 940 50 940 190 {
lab=#net11}
N 940 190 940 200 {
lab=#net11}
N 1850 -120 1960 -120 {
lab=#net13}
N 1550 0 1600 0 {
lab=#net10}
N 1580 0 1690 0 {
lab=#net10}
N 1650 0 1720 0 {
lab=#net10}
N 1690 -120 1690 -70 {
lab=#net13}
N 1630 -30 1660 -30 {
lab=#net10}
N 1630 -30 1630 0 {
lab=#net10}
N 1720 -30 1740 -30 {
lab=#net10}
N 1740 -30 1740 0 {
lab=#net10}
N 1720 0 1740 0 {
lab=#net10}
N 1690 -30 1690 0 {
lab=#net10}
N 1000 -50 1020 -50 {
lab=#net9}
N 1000 -20 1000 20 {
lab=#net10}
N 940 -50 960 -50 {
lab=#net11}
N 940 -50 940 50 {
lab=#net11}
N 940 50 960 50 {
lab=#net11}
N 1000 50 1020 50 {
lab=#net12}
N 1020 -120 1140 -120 {
lab=#net9}
N 1140 -120 1140 -80 {
lab=#net9}
N 1140 -20 1140 20 {
lab=#net10}
N 1140 80 1140 120 {
lab=#net12}
N 1020 120 1140 120 {
lab=#net12}
N 1080 50 1100 50 {
lab=#net11}
N 1080 -50 1080 50 {
lab=#net11}
N 1080 -50 1100 -50 {
lab=#net11}
N 940 0 1080 0 {
lab=#net11}
N 940 200 1070 200 {
lab=#net11}
N 1140 -50 1160 -50 {
lab=#net9}
N 1160 -120 1160 -50 {
lab=#net9}
N 1140 50 1170 50 {
lab=#net12}
N 1170 50 1170 120 {
lab=#net12}
N 1000 -20 1140 -20 {
lab=#net10}
N 2000 -120 2000 -80 {
lab=#net13}
N 2000 -50 2020 -50 {
lab=#net13}
N 2020 -120 2020 -50 {
lab=#net13}
N 2000 -20 2000 20 {
lab=#net14}
N 1940 -50 1960 -50 {
lab=#net11}
N 1940 -50 1940 50 {
lab=#net11}
N 1940 50 1960 50 {
lab=#net11}
N 2000 80 2000 120 {
lab=#net12}
N 2000 50 2020 50 {
lab=#net12}
N 2020 50 2020 120 {
lab=#net12}
N 1770 0 1940 0 {
lab=#net11}
N 1830 -20 2000 -20 {
lab=#net14}
N 2160 -120 2160 -80 {
lab=#net13}
N 2160 -50 2180 -50 {
lab=#net13}
N 2180 -120 2180 -50 {
lab=#net13}
N 2160 -20 2160 20 {
lab=#net15}
N 2100 -50 2120 -50 {
lab=#net16}
N 2100 -50 2100 50 {
lab=#net16}
N 2100 50 2120 50 {
lab=#net16}
N 2160 80 2160 120 {
lab=#net12}
N 2180 50 2180 120 {
lab=#net12}
N 2520 -40 2520 0 {
lab=#net15}
N 2300 -120 2370 -120 {
lab=#net13}
N 2430 -120 2520 -120 {
lab=#net17}
N 2520 -120 2520 -100 {
lab=#net17}
N 2720 -120 2720 -90 {
lab=#net17}
N 2720 -30 2720 0 {
lab=#net15}
N 2520 0 2720 0 {
lab=#net15}
N 3470 -120 3470 -80 {
lab=#net17}
N 3470 -50 3490 -50 {
lab=#net17}
N 3490 -120 3490 -50 {
lab=#net17}
N 3470 -20 3470 20 {
lab=#net18}
N 3410 -50 3430 -50 {
lab=#net16}
N 3410 50 3430 50 {
lab=#net16}
N 3470 80 3470 120 {
lab=#net12}
N 3470 50 3490 50 {
lab=#net12}
N 3490 50 3490 120 {
lab=#net12}
N 2160 50 2180 50 {
lab=#net12}
N 2180 50 2180 120 {
lab=#net12}
N 2160 120 2180 120 {
lab=#net12}
N 2100 50 2100 190 {
lab=#net16}
N 2100 190 2100 200 {
lab=#net16}
N 2710 0 2760 0 {
lab=#net15}
N 2740 0 2850 0 {
lab=#net15}
N 2810 0 2880 0 {
lab=#net15}
N 2850 -120 2850 -70 {
lab=#net17}
N 2790 -30 2820 -30 {
lab=#net15}
N 2790 -30 2790 0 {
lab=#net15}
N 2880 -30 2900 -30 {
lab=#net15}
N 2900 -30 2900 0 {
lab=#net15}
N 2880 0 2900 0 {
lab=#net15}
N 2850 -30 2850 0 {
lab=#net15}
N 2160 -50 2180 -50 {
lab=#net13}
N 2160 -20 2160 20 {
lab=#net15}
N 2100 -50 2120 -50 {
lab=#net16}
N 2100 -50 2100 50 {
lab=#net16}
N 2100 50 2120 50 {
lab=#net16}
N 2160 50 2180 50 {
lab=#net12}
N 2180 -120 2300 -120 {
lab=#net13}
N 2300 -120 2300 -80 {
lab=#net13}
N 2300 -20 2300 20 {
lab=#net15}
N 2300 80 2300 120 {
lab=#net12}
N 2180 120 2300 120 {
lab=#net12}
N 2240 50 2260 50 {
lab=#net16}
N 2240 -50 2240 50 {
lab=#net16}
N 2240 -50 2260 -50 {
lab=#net16}
N 2100 0 2240 0 {
lab=#net16}
N 2300 -50 2320 -50 {
lab=#net13}
N 2320 -120 2320 -50 {
lab=#net13}
N 2300 50 2330 50 {
lab=#net12}
N 2330 50 2330 120 {
lab=#net12}
N 2160 -20 2300 -20 {
lab=#net15}
N 3640 -120 3640 -80 {
lab=#net17}
N 3640 -50 3660 -50 {
lab=#net17}
N 3660 -120 3660 -50 {
lab=#net17}
N 3640 -20 3640 20 {
lab=#net18}
N 3580 -50 3600 -50 {
lab=#net16}
N 3580 -50 3580 50 {
lab=#net16}
N 3580 50 3600 50 {
lab=#net16}
N 3640 80 3640 120 {
lab=#net12}
N 3640 50 3660 50 {
lab=#net12}
N 3660 50 3660 120 {
lab=#net12}
N 3410 0 3580 0 {
lab=#net16}
N 3470 -20 3640 -20 {
lab=#net18}
N 3820 -120 3820 -80 {
lab=#net17}
N 3820 -50 3840 -50 {
lab=#net17}
N 3840 -120 3840 -50 {
lab=#net17}
N 3810 -120 3840 -120 {
lab=#net17}
N 3820 -20 3820 20 {
lab=CAP-out}
N 3760 -50 3780 -50 {
lab=#net18}
N 3760 -50 3760 50 {
lab=#net18}
N 3760 50 3780 50 {
lab=#net18}
N 3750 0 3760 0 {
lab=#net18}
N 3820 80 3820 120 {
lab=#net12}
N 3840 50 3840 120 {
lab=#net12}
N 3960 -120 4030 -120 {
lab=#net17}
N 3820 50 3840 50 {
lab=#net12}
N 3840 50 3840 120 {
lab=#net12}
N 3820 120 3840 120 {
lab=#net12}
N 3820 -50 3840 -50 {
lab=#net17}
N 3820 -20 3820 20 {
lab=CAP-out}
N 3760 -50 3780 -50 {
lab=#net18}
N 3760 -50 3760 50 {
lab=#net18}
N 3760 50 3780 50 {
lab=#net18}
N 3820 50 3840 50 {
lab=#net12}
N 3840 -120 3960 -120 {
lab=#net17}
N 3960 -120 3960 -80 {
lab=#net17}
N 3960 -20 3960 20 {
lab=CAP-out}
N 3960 80 3960 120 {
lab=#net12}
N 3840 120 3960 120 {
lab=#net12}
N 3900 50 3920 50 {
lab=#net18}
N 3900 -50 3900 50 {
lab=#net18}
N 3900 -50 3920 -50 {
lab=#net18}
N 3760 0 3900 0 {
lab=#net18}
N 3960 -50 3980 -50 {
lab=#net17}
N 3980 -120 3980 -50 {
lab=#net17}
N 3820 -20 3960 -20 {
lab=CAP-out}
N 3960 50 4010 50 {
lab=#net12}
N 4010 50 4010 120 {
lab=#net12}
N 3960 120 4010 120 {
lab=#net12}
N 3000 -40 3000 0 {
lab=#net15}
N 3000 -120 3000 -100 {
lab=#net17}
N 3200 -120 3200 -90 {
lab=#net17}
N 3200 -30 3200 0 {
lab=#net15}
N 3000 0 3200 0 {
lab=#net15}
N 3190 0 3240 0 {
lab=#net15}
N 3220 0 3330 0 {
lab=#net15}
N 3290 0 3360 0 {
lab=#net15}
N 3330 -120 3330 -70 {
lab=#net17}
N 3270 -30 3300 -30 {
lab=#net15}
N 3270 -30 3270 0 {
lab=#net15}
N 3360 -30 3380 -30 {
lab=#net15}
N 3380 -30 3380 0 {
lab=#net15}
N 3360 0 3380 0 {
lab=#net15}
N 3330 -30 3330 0 {
lab=#net15}
N 2900 0 3000 0 {
lab=#net15}
N 3640 0 3760 0 {
lab=#net18}
N 3660 -120 3820 -120 {
lab=#net17}
N 4140 -120 4140 -80 {
lab=oouutt}
N 4140 -50 4160 -50 {
lab=oouutt}
N 4160 -120 4160 -50 {
lab=oouutt}
N 4130 -120 4160 -120 {
lab=oouutt}
N 4140 -20 4140 20 {
lab=clk_out}
N 4080 -50 4100 -50 {
lab=#net18}
N 4080 -50 4080 50 {
lab=#net18}
N 4080 50 4100 50 {
lab=#net18}
N 4070 0 4080 0 {
lab=#net18}
N 4140 80 4140 120 {
lab=#net12}
N 4160 50 4160 120 {
lab=#net12}
N 4140 50 4160 50 {
lab=#net12}
N 4160 50 4160 120 {
lab=#net12}
N 4140 120 4160 120 {
lab=#net12}
N 4140 -50 4160 -50 {
lab=oouutt}
N 4140 -20 4140 20 {
lab=clk_out}
N 4080 -50 4100 -50 {
lab=#net18}
N 4080 -50 4080 50 {
lab=#net18}
N 4080 50 4100 50 {
lab=#net18}
N 4140 50 4160 50 {
lab=#net12}
N 4160 -120 4280 -120 {
lab=oouutt}
N 4280 -120 4280 -80 {
lab=oouutt}
N 4280 -20 4280 20 {
lab=clk_out}
N 4280 80 4280 120 {
lab=#net12}
N 4160 120 4280 120 {
lab=#net12}
N 4220 50 4240 50 {
lab=#net18}
N 4220 -50 4220 50 {
lab=#net18}
N 4220 -50 4240 -50 {
lab=#net18}
N 4080 0 4220 0 {
lab=#net18}
N 4280 -50 4300 -50 {
lab=oouutt}
N 4300 -120 4300 -50 {
lab=oouutt}
N 4140 -20 4280 -20 {
lab=clk_out}
N 4280 50 4330 50 {
lab=#net12}
N 4330 50 4330 120 {
lab=#net12}
N 4280 120 4330 120 {
lab=#net12}
N 4020 120 4140 120 {
lab=#net12}
N 4090 -120 4130 -120 {
lab=oouutt}
N 4270 -120 4300 -120 {
lab=oouutt}
N 4300 -120 4370 -120 {
lab=oouutt}
N 3710 0 3710 180 {
lab=#net18}
N 4080 50 4080 180 {
lab=#net18}
N 3710 180 4080 180 {
lab=#net18}
N 0 -0 220 -0 {
lab=#net1}
N 1140 0 1360 0 {
lab=#net10}
N 2300 0 2520 0 {
lab=#net15}
N 4010 120 4040 120 {
lab=#net12}
N 3960 0 3970 0 {
lab=CAP-out}
N 4280 0 4300 0 {
lab=clk_out}
N 420 0 600 -0 {
lab=#net1}
N 220 -120 550 -120 {
lab=#net2}
N 3470 -120 3660 -120 {
lab=#net17}
N 3470 120 3820 120 {
lab=#net12}
N 2300 120 3470 120 {
lab=#net12}
N 2520 -120 3470 -120 {
lab=#net17}
N 2100 200 3410 200 {
lab=#net16}
N 3410 -50 3410 200 {
lab=#net16}
N 1960 -120 2180 -120 {
lab=#net13}
N 1830 120 2160 120 {
lab=#net12}
N 1360 -120 1850 -120 {
lab=#net13}
N 1140 120 1830 120 {
lab=#net12}
N 1070 200 1770 200 {
lab=#net11}
N 1770 50 1770 200 {
lab=#net11}
N 860 -120 1020 -120 {}
N 690 120 1000 120 {}
N 690 -120 860 -120 {}
N 840 0 940 0 {}
N 550 -120 690 -120 {}
N 0 120 620 120 {}
N -70 200 610 200 {}
N 610 50 610 200 {}
N 2000 -0 2100 -0 {}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -160 50 0 0 {name=M1
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/ipin.sym} -210 0 0 0 {name=p1 lab=clk}
C {devices/iopin.sym} -210 -120 2 0 {name=p2 lab=in}
C {sky130_fd_pr/diode.sym} 100 -120 1 0 {name=D1
model=diode_pd2nw_05v5_hvt
area=31.799e12
pj=22.6e6
}
C {devices/iopin.sym} -210 120 2 0 {name=p3 lab=gnd
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 220 -70 0 0 {name=C1 model=cap_mim_m3_1 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 420 -60 2 0 {name=C2 model=cap_mim_m3_2 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 650 50 0 0 {name=M5
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 650 -50 0 0 {name=M6
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 550 -50 1 0 {name=M7
L=30
W=60
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -160 -50 0 0 {name=M2
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -20 50 0 0 {name=M4
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -20 -50 0 0 {name=M8
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 820 50 0 0 {name=M3
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 820 -50 0 0 {name=M9
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 980 50 0 0 {name=M10
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/diode.sym} 1240 -120 1 0 {name=D2
model=diode_pd2nw_05v5_hvt
area=31.799e12
pj=22.6e6

}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1360 -70 0 0 {name=C3 model=cap_mim_m3_1 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 1560 -60 2 0 {name=C4 model=cap_mim_m3_2 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1810 50 0 0 {name=M11
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1810 -50 0 0 {name=M12
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1690 -50 1 0 {name=M13
L=30
W=60
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 980 -50 0 0 {name=M14
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1120 50 0 0 {name=M15
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1120 -50 0 0 {name=M16
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1980 50 0 0 {name=M17
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1980 -50 0 0 {name=M18
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2140 50 0 0 {name=M19
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/diode.sym} 2400 -120 1 0 {name=D3
model=diode_pd2nw_05v5_hvt
area=31.799e12
pj=22.6e6
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2520 -70 0 0 {name=C5 model=cap_mim_m3_1 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 2720 -60 2 0 {name=C6 model=cap_mim_m3_2 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3450 50 0 0 {name=M20
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3450 -50 0 0 {name=M21
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2850 -50 1 0 {name=M22
L=30
W=60
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2140 -50 0 0 {name=M23
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2280 50 0 0 {name=M24
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2280 -50 0 0 {name=M25
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3620 50 0 0 {name=M26
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3620 -50 0 0 {name=M27
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3800 50 0 0 {name=M28
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/diode.sym} 4060 -120 1 0 {name=D4
model=diode_pd2nw_05v5_hvt
area=37.8e12
pj=24.6e6
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3800 -50 0 0 {name=M32
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3940 50 0 0 {name=M33
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3940 -50 0 0 {name=M34
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/cap_mim_m3_1.sym} 3000 -70 0 0 {name=C7 model=cap_mim_m3_1 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/cap_mim_m3_2.sym} 3200 -60 2 0 {name=C8 model=cap_mim_m3_2 W=30 L=30 MF=2 spiceprefix=X}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 3330 -50 1 0 {name=M29
L=30
W=60
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/iopin.sym} 4370 -120 0 0 {name=p4 lab=oouutt
}
C {devices/iopin.sym} 3970 0 0 0 {name=p5 lab=CAP-out

}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4120 50 0 0 {name=M30
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4120 -50 0 0 {name=M31
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 4260 50 0 0 {name=M35
L=0.5
W=12
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 4260 -50 0 0 {name=M36
L=0.5
W=24
nf=16
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/iopin.sym} 4300 0 0 0 {name=p6 lab=clk_out

}
